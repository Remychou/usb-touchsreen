# Keil uVision project HID_TP_CAP.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: HID_TP_GT_V100 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Debug.C DEVICE.C IIC.C MAIN.C GT911.C README.TXT FLASH_IC.C
