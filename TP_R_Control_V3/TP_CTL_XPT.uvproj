# Keil uVision project TP_CTL_XPT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: TP_CTL_XPT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Myfile
  group Myfile
    ./Myfile/: DEBUG.C main.c XPT2046.C DEVICE.C
