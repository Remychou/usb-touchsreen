# Keil uVision project HID_TP_FT.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: HID_TP_CY_V100 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: Debug.C DEVICE.C IIC.C MAIN.C FT5206.C FLASH_IC.C
